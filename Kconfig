## vocdrv_ld20/Kconfig
```kconfig
config UNIPHIER_VOCDRV
	tristate "VOC driver for UniPhier"
	depends on ARCH_UNIPHIER
```
